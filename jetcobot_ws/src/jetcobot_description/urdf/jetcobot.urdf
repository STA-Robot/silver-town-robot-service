Commit message: feat: Simplify TCP link definition in URDF by removing visual elements

File: jetcobot_ws/src/jetcobot_description/urdf/jetcobot.urdf (robot description, URDF)
Before this commit: robot jetcobot, 13 links, 12 joints
Links:
- link TCP: geometry 
